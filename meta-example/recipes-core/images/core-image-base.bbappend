IMAGE_INSTALL += " \
  openssh \
  bootgen \
"
